v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {TgateVinj02/ihp130_TgateVinj02.sym} -30 0 1 0 {name=x1}
C {TgateVinj02/ihp130_TgateVinj02.sym} 170 0 1 0 {name=x2}
C {TgateVinj02/ihp130_TgateVinj02.sym} 370 0 1 0 {name=x3}
C {TgateVinj02/ihp130_TgateVinj02.sym} 570 0 1 0 {name=x4}
